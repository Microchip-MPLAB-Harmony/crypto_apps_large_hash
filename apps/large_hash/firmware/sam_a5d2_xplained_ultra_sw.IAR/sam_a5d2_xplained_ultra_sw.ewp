# IAR project sam_a5d2_xplained_ultra_sw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMA5D27 Microchip ATSAMA5D27
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 50
  General.FPU2: 5
  ICCARM.CCDefines: HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; __FPU_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\sam_a5d2_xplained_ultra_sw; ..\..\firmware\src\packs\ATSAMA5D27_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core_A\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm; ..\..\firmware\src\third_party\wolfssl; ..\..\firmware\src\third_party\wolfssl\wolfssl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: harmony.bin
  ILINK.IlinkOutputFile: sam_a5d2_xplained_ultra_sw.out
  ILINK.IlinkIcfFile: ..\..\firmware\src\config\sam_a5d2_xplained_ultra_sw\ddr.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; HAVE_CONFIG_H; WOLFSSL_IGNORE_FILE_WARN; __FPU_PRESENT=1
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/sam_a5d2_xplained_ultra_sw/: sam_a5d2_xplained_ultra_sw.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAMA5D27_DFP/component/: acc.h adc.h aes.h aesb.h aic.h aximx.h chipid.h classd.h flexcom.h gmac.h i2sc.h icm.h isc.h l2cc.h lcdc.h matrix.h mcan.h mpddrc.h pdmic.h pio.h pio_ctrl.h pit.h pmc.h ptc.h pwm.h qspi.h rstc.h rtc.h rxlp.h sckc.h sdmmc.h secumod.h sfc.h sfr.h sfrbu.h sha.h shdwc.h smc.h spi.h ssc.h tc.h tdes.h trng.h twihs.h uart.h udphs.h uhphs.h wdt.h xdmac.h
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/: aes.h arc4.h asn.h asn_public.h blake2-impl.h blake2-int.h blake2.h camellia.h chacha.h chacha20_poly1305.h cmac.h coding.h compress.h cpuid.h cryptocb.h curve25519.h des3.h dh.h dsa.h ecc.h ed25519.h error-crypt.h fe_operations.h fips_test.h ge_operations.h hash.h hc128.h hmac.h idea.h integer.h logging.h md2.h md4.h md5.h mem_track.h memory.h misc.h mpi_class.h mpi_superclass.h pkcs11.h pkcs12.h pkcs7.h poly1305.h pwdbased.h rabbit.h random.h ripemd.h rsa.h selftest.h settings.h sha.h sha256.h sha3.h sha512.h signature.h sp.h sp_int.h srp.h tfm.h types.h visibility.h wc_encrypt.h wc_pkcs11.h wc_port.h wolfevent.h wolfmath.h
    ../src/: app.h
    ../src/packs/ATSAMA5D27_DFP/: atsama5d27.h device.h
    ../src/third_party/wolfssl/wolfssl/: certs_test.h
    ../src/packs/CMSIS/CMSIS/Core_A/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h core_ca.h
    ../src/config/sam_a5d2_xplained_ultra_sw/: config.h configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/port/pic32/: crypt_aes_hw.h crypt_aes_hwInt.h crypt_aes_sam6149.h crypt_aes_u2238.h crypt_crya_saml11.h crypt_ecc_ba414e.h crypt_ecc_pukcl.h crypt_pukcl_definitions.h crypt_pukcl_functions.h crypt_rng_hw.h crypt_rsa_pukcl.h crypt_sha1_hw.h crypt_sha224_hw.h crypt_sha256_hw.h crypt_sha384_hw.h crypt_sha512_hw.h crypt_sha_hw.h crypt_sha_sam11105.h crypt_sha_sam6156.h crypt_tdes_hw.h crypt_tdes_hwInt.h crypt_tdes_sam6150.h crypt_wolfcryptcb.h CryptoLib_cf_pb.h CryptoLib_ClearFlags_pb.h CryptoLib_Comp_pb.h CryptoLib_CondCopy_pb.h CryptoLib_CRT_pb.h CryptoLib_Div_pb.h CryptoLib_ExpMod_pb.h CryptoLib_FastCopy_pb.h CryptoLib_Fill_pb.h CryptoLib_Fmult_pb.h CryptoLib_GCD_pb.h CryptoLib_GF2NEccAdd_pb.h CryptoLib_GF2NEccConv_pb.h CryptoLib_GF2NEccDbl_pb.h CryptoLib_GF2NEccMul_pb.h CryptoLib_GF2NEcDsa_pb.h CryptoLib_Hardware_pb.h CryptoLib_Headers_pb.h CryptoLib_JumpTable_pb.h CryptoLib_mapping_pb.h CryptoLib_PrimeGen_pb.h CryptoLib_Rc_pb.h CryptoLib_RedMod_pb.h CryptoLib_Rng_pb.h CryptoLib_SelfTest_pb.h CryptoLib_Services_pb.h CryptoLib_Smult_pb.h CryptoLib_Square_pb.h CryptoLib_Swap_pb.h CryptoLib_typedef_pb.h CryptoLib_ZpEccAdd_pb.h CryptoLib_ZpEccAddSub_pb.h CryptoLib_ZpEccConv_pb.h CryptoLib_ZpEccDbl_pb.h CryptoLib_ZpEccMul_pb.h CryptoLib_ZpEccQuickDualMul_pb.h CryptoLib_ZpEcDsa_pb.h pic32mz-crypt.h
    ../src/config/sam_a5d2_xplained_ultra_sw/crypto/: crypto.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/: driver.h driver_common.h
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/usart/: drv_usart.h drv_usart_definitions.h
    ../src/config/sam_a5d2_xplained_ultra_sw/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/aic/: plib_aic.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/clk/: plib_clk.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix/: plib_matrix.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu/: plib_mmu.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pio/: plib_pio.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pit/: plib_pit.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/uart/: plib_uart1.h plib_uart_common.h
    ../src/packs/ATSAMA5D27_DFP/pio/: sama5d27.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/cache/: sys_cache.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/dma/: sys_dma.h sys_dma_mapping.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/src/: sys_time_local.h
    ../src/config/sam_a5d2_xplained_ultra_sw/system/: system.h system_common.h system_module.h
  group IAR Project Connection File/Source Files
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c blake2s.c camellia.c chacha.c chacha20_poly1305.c cmac.c coding.c compress.c cpuid.c cryptocb.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs12.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha3.c sha512.c signature.c sp_arm32.c sp_arm64.c sp_armthumb.c sp_c32.c sp_c64.c sp_cortexm.c sp_int.c sp_x86_64.c srp.c tfm.c wc_encrypt.c wc_pkcs11.c wc_port.c wolfevent.c wolfmath.c
    ../src/: app.c main.c
    ../src/third_party/wolfssl/wolfssl/wolfcrypt/src/port/pic32/: crypt_aes_sam6149.c crypt_aes_u2238.c crypt_ecc_ba414e.c crypt_ecc_pukcl.c crypt_pukcl_functions.c crypt_rng_sam6334.c crypt_rng_u2242.c crypt_rsa_pukcl.c crypt_sam_u2803.c crypt_sha1_sam11105.c crypt_sha1_sam6156.c crypt_sha224_sam11105.c crypt_sha224_sam6156.c crypt_sha256_sam11105.c crypt_sha256_sam6156.c crypt_sha384_sam6156.c crypt_sha512_sam6156.c crypt_tdes_sam6150.c crypt_wolfcryptcb.c pic32mz-crypt.c
    ../src/config/sam_a5d2_xplained_ultra_sw/crypto/src/: crypto.c
    ../src/config/sam_a5d2_xplained_ultra_sw/: cstartup.s fault_handlers.c initialization.c interrupts.c tasks.c
    ../src/config/sam_a5d2_xplained_ultra_sw/driver/usart/src/: drv_usart.c drv_usart_local.h
    ../src/config/sam_a5d2_xplained_ultra_sw/stdio/: iar_monitor.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/aic/: plib_aic.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/clk/: plib_clk.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/matrix/: plib_matrix.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/mmu/: plib_mmu.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pio/: plib_pio.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/pit/: plib_pit.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/tc/: plib_tc0.c
    ../src/config/sam_a5d2_xplained_ultra_sw/peripheral/uart/: plib_uart1.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/cache/: sys_cache.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/dma/: sys_dma.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/int/src/: sys_int.c
    ../src/config/sam_a5d2_xplained_ultra_sw/system/time/src/: sys_time.c
